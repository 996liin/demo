# Keil uVision project template.uvprojx, settings and files
target GD32F470VG (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F470VG GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.4
  cpu: IROM(0x08000000,0x0100000) IRAM(0x20000000,0x070000) IRAM2(0x10000000,0x010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Firmware\CMSIS;.\Firmware\GD32F4xx_standard_peripheral\Include;.\Firmware\CMSIS\GD\GD32F4xx\Include;.\code\ARMA;.\code\ARMB_DZ;.\code\PowerCtrl;.\code\Code_All
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x70000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group main
    ./main/: main.c
  group Code_ARMA
    ./code/ARMA/: at24cxx.c flash.c iap.c queue.c systick.c timer.c usart.c iap_flag.c
  group Startup
    ./Firmware/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f450_470.s
  group Core
    ./Firmware/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
    ./Firmware/CMSIS/: core_cm4.h gd32f4xx_it.c
  group Firmware
    ./Firmware/GD32F4xx_standard_peripheral/Source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
